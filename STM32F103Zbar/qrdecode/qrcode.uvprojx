# Keil uVision project qrcode.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: qrcode +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD.USE_STDPERIPH_DRIVER,NDEBUG
  c include: STM32F10X_HD.USE_STDPERIPH_DRIVER;.\lib;.\user;.\lib\ATKQR;.\lib\Malloc;.\lib\zbar;.\lib\zbar\decoder;.\lib\zbar\qrcode;.\lib\sram;.\lib\24CXX;.\lib\delay;.\lib\exti;.\lib\IIC;.\lib\key;.\lib\LCD;.\lib\led;.\lib\sccb;.\lib\SPI;.\lib\time;.\lib\TOUCH;.\lib\USART;.\lib\ov7670;.\lib\sys;.\lib\exti;.\lib\my_stm32f10x_exti;.\lib\my_stm32f10x_spi;.\lib\buzzle;.\lib\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c
  group lib
    ./lib/: init.c
    ./lib/sram/: sram.c
  group Malloc
    ./lib/Malloc/: malloc.c
  group Zbar
    ./lib/zbar/: config.c decoder.c image.c img_scanner.c refcnt.c scanner.c symbol.c error.c zbar_config.c
  group Zbar/qrcode
    ./lib/zbar/qrcode/: bch15_5.c binarize.c isaac.c qrdec.c qrdectxt.c rs.c util.c
  group Zbar/finder
    ./lib/zbar/decoder/: qr_finder.c
  group camera
    ./lib/24CXX/: 24cxx.c 24cxx.h
    ./lib/IIC/: myiic.c myiic.h
    ./lib/LCD/: FONT.H lcd.c lcd.h
    ./lib/Malloc/: malloc.h
    ./lib/ov7670/: ov7670.c ov7670.h ov7670cfg.h
    ./lib/sccb/: sccb.c sccb.h
    ./lib/time/: time.c time.h
    ./lib/sys/: sys.c sys.h
    ./lib/SPI/: SPI.c SPI.h
    ./lib/my_stm32f10x_exti/: my_stm32f10x_exti.c my_stm32f10x_exti.h
    ./lib/my_stm32f10x_spi/: my_stm32f10x_spi.c my_stm32f10x_spi.h
    ./lib/buzzle/: Buzzle.c Buzzle.h
    ./lib/led/: led.c led.h
software components: CMSIS:CORE 5.5.0, Device:DMA 1.3, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
